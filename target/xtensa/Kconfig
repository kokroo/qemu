## target/xtensa/Kconfig
```kconfig
config XTENSA
    bool
	imply SEMIHOSTING if TCG
	select ARM_COMPATIBLE_SEMIHOSTING if TCG
```
